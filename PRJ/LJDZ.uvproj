# Keil uVision project LJDZ.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: LJDZ +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\INC
  group Source Group 1
    ./: STARTUP.A51
    ../SCR/: autorun.c Main.c buzz.c err.c output.c clk.c USART.C input.c motor.c run.c EEPROM.c romtest.c Wg34.c
